# Keil uVision project Stm32_Learn.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32_Learn +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Driver;.\Hardware\KEY;.\Hardware\LED;.\Hardware\EXTI0;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: stm32f10x_conf.h main_gpio_stdlib.c
  group Hardware
    ./Hardware/KEY/: key.c key.h
    ./Hardware/LED/: led.c led.h
    ./Hardware/EXTI0/: exti0.c exti0.h
  group Driver
    ./Driver/: delay.c delay.h
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
